# Keil uVision project burst_mode.uvprojx, settings and files
target burst_mode (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: burst_mode
  AfterMake: fromelf --bin --output bin\burst_mode.bin bin\burst_mode.axf
  AfterMake: fromelf -cedrst --output bin\burst_mode.txt bin\burst_mode.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO3 AM_PACKAGE_BGA AM_UTIL_FAULTISR_PRINT keil
  c include: ../../../../../devices;../../../../../CMSIS/ARM/Include;../../../../../utils;../../../../..;../../../../../CMSIS/AmbiqMicro/Include;../../../../../mcu/apollo3;../src;../../../bsp
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\burst_mode.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: burst_mode.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
