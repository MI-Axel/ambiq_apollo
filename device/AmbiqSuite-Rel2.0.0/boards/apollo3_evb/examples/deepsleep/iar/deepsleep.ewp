# IAR project deepsleep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\utils; ..\..\..\..\..; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\devices; ..\..\..\bsp; ..\src; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\mcu\apollo3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: deepsleep.bin
  ILINK.IlinkOutputFile: deepsleep.out
  ILINK.IlinkIcfFile: deepsleep.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO3
  group (top)
    ../src/: deepsleep.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
