# IAR project coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; COREMARK; AM_PACKAGE_BGA; AM_PART_APOLLO3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\bsp; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\utils; ..\src; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..; ..\..\..\..\..\devices
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: coremark.bin
  ILINK.IlinkOutputFile: coremark.out
  ILINK.IlinkIcfFile: coremark.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; COREMARK; AM_PACKAGE_BGA; AM_PART_APOLLO3
  group (top)
    ../src/: am_time.c coremark.c core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
    ../../../../../devices/: am_devices_led.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
