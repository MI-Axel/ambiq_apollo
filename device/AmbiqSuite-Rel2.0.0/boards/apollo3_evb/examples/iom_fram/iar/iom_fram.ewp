# IAR project iom_fram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO3; AM_PACKAGE_BGA; FIREBALL_CARD=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\utils; ..\src; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\bsp; ..\..\..\..\..; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: iom_fram.bin
  ILINK.IlinkOutputFile: iom_fram.out
  ILINK.IlinkIcfFile: iom_fram.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO3; AM_PACKAGE_BGA; FIREBALL_CARD=1
  group (top)
    ../src/: iom_fram.c
    ../../../../../devices/: am_devices_fireball.c am_devices_mb85rc256v.c am_devices_mb85rs1mt.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
