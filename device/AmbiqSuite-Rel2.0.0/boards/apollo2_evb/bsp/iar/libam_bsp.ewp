# IAR project libam_bsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO2; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\apollo2; ..\..\..\..\devices
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: libam_bsp.bin
  ILINK.IlinkOutputFile: libam_bsp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  group (top)
    ../: am_bsp.c
