# IAR project freertos_amdtpc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; WSF_TRACE_ENABLED; AM_DEBUG_PRINTF; BLE_MENU; AM_FREERTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\ambiq_ble\menu; ..\..\..\..\..\ambiq_ble\services; ..\..\..\..\..\third_party\exactle\sw\profiles\gatt; ..\..\..\..\..\third_party\exactle\ws-core\sw\wsf\ambiq; ..\..\..\..\..\third_party\exactle\sw\profiles\uribeacon; ..\..\..\..\..\third_party\uecc\micro-ecc; ..\..\..\..\..\third_party\exactle\ws-core\include; ..\..\..\..\..\third_party\exactle\sw\sec\common; ..\..\..\..\..\third_party\exactle\ws-core\sw\wsf\include; ..\..\..\..\..\third_party\FreeRTOS9\Source\portable\IAR\AMapollo2; ..\..\..\..\..\ambiq_ble\apps\amdtpc; ..\..\..\..\..\third_party\exactle\sw\apps\app; ..\..\..\..\..\ambiq_ble\profiles\amdtpcommon; ..\..\..\..\..\third_party\exactle\sw\profiles\hid; ..\..\..\..\..\devices; ..\..\..\..\..\third_party\exactle\sw\services; ..\..\..\..\..\mcu\apollo2; ..\..\..\..\..\third_party\exactle\sw\hci\include; ..\..\..\..\..\ambiq_ble\profiles\amdtpc; ..\..\..\..\..\third_party\FreeRTOS9\Source\include; ..\..\..\bsp; ..\..\..\..\..\third_party\exactle\sw\sec\include; ..\..\..\..\..\third_party\exactle\sw\stack\include; ..\..\..\..\..\third_party\exactle\sw\stack\cfg; ..\..\..\..\..\third_party\exactle\sw\apps\app\include; ..\..\..\..\..\third_party\exactle\ws-core\sw\util; ..\src; ..\..\..\..\..\third_party\exactle\sw\profiles\bas; ..\..\..\..\..\third_party\exactle\sw\hci\ambiq; ..\..\..\..\..\ambiq_ble\em9304; ..\..\..\..\..\third_party\exactle\sw\profiles\gap; ..\..\..\..\..\third_party\exactle\sw\stack\hci; ..\..\..\..\..\third_party\exactle\sw\hci\ambiq\em9304; ..\..\..\..\..\utils; ..\..\..\..\..\third_party\exactle\apollo-host\projects\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_amdtpc.bin
  ILINK.IlinkOutputFile: freertos_amdtpc.out
  ILINK.IlinkIcfFile: freertos_amdtpc.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\third_party\exactle\projects\generic\stacklib\iar\bin\stacklib.a; ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo2\hal\iar\bin\libam_hal.a; ..\..\..\..\..\third_party\uecc\iar\bin\lib_uecc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; WSF_TRACE_ENABLED; AM_DEBUG_PRINTF; BLE_MENU; AM_FREERTOS
  group (top)
    ../../../../../ambiq_ble/menu/: ble_menu.c
    ../../../../../third_party/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
    ../../../../../third_party/exactle/sw/apps/hidapp/: hidapp_main.c
    ../../../../../ambiq_ble/profiles/amdtpc/: amdtpc_main.c
    ../../../../../third_party/exactle/sw/profiles/gatt/: gatt_main.c
    ../../../../../third_party/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
    ../../../../../third_party/exactle/sw/stack/cfg/: cfg_stack.c
    ../../../../../third_party/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
    ../../../../../third_party/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../src/: freertos_amdtp.c radio_task.c rtos.c
    ../../../../../third_party/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
    ../../../../../third_party/FreeRTOS9/Source/portable/IAR/AMapollo2/: port.c portasm.s
    ../../../../../ambiq_ble/apps/amdtpc/: amdtp_main.c
    ../../../../../ambiq_ble/profiles/amdtpcommon/: amdtp_common.c
    ../../../../../third_party/exactle/sw/profiles/hid/: hid_main.c
    ../../../../../third_party/exactle/sw/profiles/bas/: bas_main.c
    ../../../../../third_party/exactle/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
    ../../../../../ambiq_ble/em9304/: em9304_init.c em9304_patches.c
    ../../../../../third_party/exactle/sw/profiles/gap/: gap_main.c
    ../../../../../third_party/exactle/sw/stack/hci/: hci_main.c
    ../../../../../third_party/exactle/sw/hci/ambiq/em9304/: hci_drv_em9304.c
    ../../../../../third_party/exactle/sw/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../../third_party/FreeRTOS9/Source/portable/MemMang/: heap_2.c
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../devices/: am_devices_button.c am_devices_em9304.c am_devices_led.c
    ../../../../../third_party/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ./: startup_iar.c
