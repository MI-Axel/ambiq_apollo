# IAR project mindtree_ancs.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512-KBR AmbiqMicro APOLLO512-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; ANCS; BT_STORAGE; ATT_CLIENT; APPL_FSM_SUPPORT; APPL_GAP_PERIPHERAL_SUPPORT; GAP_PERIPHERAL; GATT_DB; HAVE_FREERTOS_STUB; AM_DEBUG_PRINTF; BT_ENABLE_DISABLE_RUNTIME_DEBUG; AM_FREERTOS; DONT_USE_STANDARD_IO; AM_PART_APOLLO; AM_FREERTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\ambiq_ble\em9304; ..\..\..\..\..\ambiq_ble\profile_appl\ancs; ..\..\..\..\..\devices; ..\..\..\..\..\mcu\apollo; ..\..\..\..\..\third_party\ethermind\appl\profile_appl; ..\..\..\..\..\third_party\ethermind\include; ..\..\..\..\..\third_party\ethermind\os\freertos; ..\..\..\..\..\utils; ..\..\..\bsp; ..\src; ..\..\..\..\..\third_party\FreeRTOS9\Source\include; ..\..\..\..\..\third_party\FreeRTOS9\Source\portable\MemMang; ..\..\..\..\..\third_party\FreeRTOS9\Source\portable\IAR\AMapollo
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mindtree_ancs.bin
  ILINK.IlinkOutputFile: mindtree_ancs.out
  ILINK.IlinkIcfFile: mindtree_ancs.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo\hal\iar\bin\libam_hal.a; ..\..\..\..\..\third_party\ethermind\library\freertos\iar\ethermind.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; ANCS; BT_STORAGE; ATT_CLIENT; APPL_FSM_SUPPORT; APPL_GAP_PERIPHERAL_SUPPORT; GAP_PERIPHERAL; GATT_DB; HAVE_FREERTOS_STUB; AM_DEBUG_PRINTF; BT_ENABLE_DISABLE_RUNTIME_DEBUG; AM_FREERTOS; DONT_USE_STANDARD_IO; AM_PART_APOLLO; AM_FREERTOS
  group (top)
    ../../../../../third_party/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/FreeRTOS9/Source/portable/MemMang/: heap_2.c
    ../../../../../ambiq_ble/em9304/: em9304_init.c em9304_patches.c
    ../../../../../ambiq_ble/profile_appl/ancs/: appl_ancs.c appl_ancs_att_server.c appl_gap_config_params.c gatt_db.c
    ../src/: mindtree_ancs.c rtos.c
    ../../../../../third_party/FreeRTOS9/Source/portable/IAR/AMapollo/: port.c portasm.s
    ../../../../../devices/: am_devices_em9304.c am_devices_led.c
    ../../../../../third_party/ethermind/appl/profile_appl/: appl.c appl_fsm_handlers.c appl_fsm_table.c appl_gap.c appl_hci.c appl_smp.c
    ../../../../../third_party/ethermind/os/freertos/: BT_debug.c gatt_db_pl.c hci_spi_em9304.c status_pl.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
