# Keil uVision project mindtree_amota.uvprojx, settings and files
target mindtree_amota (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mindtree_amota
  AfterMake: fromelf --bin --output bin\mindtree_amota.bin bin\mindtree_amota.axf
  AfterMake: fromelf -cedrst --output bin\mindtree_amota.txt bin\mindtree_amota.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AMOTAS APPL_FSM_SUPPORT APPL_GAP_PERIPHERAL_SUPPORT GAP_PERIPHERAL GATT_DB APPL_ATT_SERVER HAVE_FREERTOS_STUB DONT_USE_STANDARD_IO AM_MULTIBOOT_CONFIG_FILE=\"amota_profile_config.h\" AM_DEBUG_PRINTF BT_ENABLE_DISABLE_RUNTIME_DEBUG AM_PART_APOLLO2 AM_FREERTOS keil
  c include: ../../../../..;../../../../../ambiq_ble/em9304;../../../../../ambiq_ble/profile_appl/amota;../../../../../bootloader;../../../../../devices;../../../../../mcu/apollo2;../../../../../third_party/ethermind/appl/profile_appl;../../../../../third_party/ethermind/include;../../../../../third_party/ethermind/os/freertos;../../../../../utils;../../../bsp;../src;../../../../../third_party/FreeRTOS9/Source/include;../../../../../third_party/FreeRTOS9/Source/portable/MemMang;../../../../../third_party/FreeRTOS9/Source/portable/Keil/AMapollo2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\mindtree_amota.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group Source
    ../../../../../third_party/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group MemMang
    ../../../../../third_party/FreeRTOS9/Source/portable/MemMang/: heap_2.c
  group em9304
    ../../../../../ambiq_ble/em9304/: em9304_init.c em9304_patches.c
  group amota
    ../../../../../ambiq_ble/profile_appl/amota/: appl_amota.c appl_gap_config_params.c gatt_db.c
  group src
    ../src/: amota_crc32.c extflash.c mindtree_main.c rtos.c
  group AMapollo2
    ../../../../../third_party/FreeRTOS9/Source/portable/Keil/AMapollo2/: port.c
  group bootloader
    ../../../../../bootloader/: am_bootloader.c am_multi_boot.c
  group devices
    ../../../../../devices/: am_devices_em9304.c am_devices_led.c am_devices_spiflash.c
  group profile_appl
    ../../../../../third_party/ethermind/appl/profile_appl/: appl.c appl_att_server.c appl_fsm_handlers.c appl_fsm_table.c appl_gap.c appl_hci.c appl_smp.c
  group freertos
    ../../../../../third_party/ethermind/os/freertos/: BT_debug.c gatt_db_pl.c hci_spi_em9304.c status_pl.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
    ../../../../../third_party/ethermind/library/freertos/keil/: ethermind.lib
