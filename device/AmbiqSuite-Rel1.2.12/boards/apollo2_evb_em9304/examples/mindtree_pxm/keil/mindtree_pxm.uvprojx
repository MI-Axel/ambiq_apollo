# Keil uVision project mindtree_pxm.uvprojx, settings and files
target mindtree_pxm (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mindtree_pxm
  AfterMake: fromelf --bin --output bin\mindtree_pxm.bin bin\mindtree_pxm.axf
  AfterMake: fromelf -cedrst --output bin\mindtree_pxm.txt bin\mindtree_pxm.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA APPL_GAP_CENTRAL_SUPPORT GAP_CENTRAL GAP_OBSERVER APPL_ATT_CLIENT ATT_CLIENT HAVE_FREERTOS_STUB DONT_USE_STANDARD_IO AM_FREERTOS APPL_MENU_OPS AM_DEBUG_PRINTF BT_ENABLE_DISABLE_RUNTIME_DEBUG AM_PART_APOLLO2 AM_FREERTOS keil
  c include: ../../../../..;../../../../../ambiq_ble/em9304;../../../../../devices;../../../../../mcu/apollo2;../../../../../third_party/ethermind/appl/profile_appl;../../../../../third_party/ethermind/appl/profile_appl/pxm;../../../../../third_party/ethermind/include;../../../../../third_party/ethermind/os/freertos;../../../../../utils;../../../bsp;../src;../../../../../third_party/FreeRTOS9/Source/include;../../../../../third_party/FreeRTOS9/Source/portable/MemMang;../../../../../third_party/FreeRTOS9/Source/portable/Keil/AMapollo2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\mindtree_pxm.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group Source
    ../../../../../third_party/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group MemMang
    ../../../../../third_party/FreeRTOS9/Source/portable/MemMang/: heap_2.c
  group em9304
    ../../../../../ambiq_ble/em9304/: em9304_init.c em9304_patches.c
  group pxm
    ../../../../../third_party/ethermind/appl/profile_appl/pxm/: appl_pxm.c
  group src
    ../src/: mindtree_pxm.c rtos.c
  group AMapollo2
    ../../../../../third_party/FreeRTOS9/Source/portable/Keil/AMapollo2/: port.c
  group devices
    ../../../../../devices/: am_devices_em9304.c am_devices_led.c
  group freertos
    ../../../../../third_party/ethermind/os/freertos/: BT_debug.c hci_spi_em9304.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
    ../../../../../third_party/ethermind/library/freertos/keil/: ethermind.lib
