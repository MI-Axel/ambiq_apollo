# IAR project mindtree_amota.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AMOTAS; APPL_FSM_SUPPORT; APPL_GAP_PERIPHERAL_SUPPORT; GAP_PERIPHERAL; GATT_DB; APPL_ATT_SERVER; DONT_USE_STANDARD_IO; AM_MULTIBOOT_CONFIG_FILE="amota_profile_config.h"; AM_DEBUG_PRINTF; BT_ENABLE_DISABLE_RUNTIME_DEBUG; AM_CUSTOM_BDADDR; AM_PART_APOLLO3; AM_FREERTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\ambiq_ble\profile_appl\amota; ..\..\..\..\..\bootloader; ..\..\..\..\..\devices; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\third_party\ethermind\appl\profile_appl; ..\..\..\..\..\third_party\ethermind\include; ..\..\..\..\..\third_party\ethermind\os\freertos; ..\..\..\..\..\third_party\ethermind\os\freertos\apollo3; ..\..\..\..\..\utils; ..\..\..\bsp; ..\src; ..\..\..\..\..\third_party\FreeRTOS9\Source\include; ..\..\..\..\..\third_party\FreeRTOS9\Source\portable\MemMang; ..\..\..\..\..\third_party\FreeRTOS9\Source\portable\IAR\AMapollo2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mindtree_amota.bin
  ILINK.IlinkOutputFile: mindtree_amota.out
  ILINK.IlinkIcfFile: mindtree_amota.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\..\..\third_party\ethermind\library\freertos\iar\ethermind.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AMOTAS; APPL_FSM_SUPPORT; APPL_GAP_PERIPHERAL_SUPPORT; GAP_PERIPHERAL; GATT_DB; APPL_ATT_SERVER; DONT_USE_STANDARD_IO; AM_MULTIBOOT_CONFIG_FILE="amota_profile_config.h"; AM_DEBUG_PRINTF; BT_ENABLE_DISABLE_RUNTIME_DEBUG; AM_CUSTOM_BDADDR; AM_PART_APOLLO3; AM_FREERTOS
  group (top)
    ../../../../../third_party/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/FreeRTOS9/Source/portable/MemMang/: heap_2.c
    ../../../../../ambiq_ble/profile_appl/amota/: appl_amota.c appl_gap_config_params.c gatt_db.c
    ../../../../../third_party/ethermind/os/freertos/apollo3/: hci_drv_apollo3.c
    ../src/: amota_crc32.c mindtree_main.c rtos.c
    ../../../../../third_party/FreeRTOS9/Source/portable/IAR/AMapollo2/: port.c portasm.s
    ../../../../../bootloader/: am_bootloader.c am_multi_boot.c
    ../../../../../devices/: am_devices_button.c am_devices_led.c
    ../../../../../third_party/ethermind/appl/profile_appl/: appl.c appl_att_server.c appl_fsm_handlers.c appl_fsm_table.c appl_gap.c appl_hci.c appl_smp.c
    ../../../../../third_party/ethermind/os/freertos/: BT_debug.c gatt_db_pl.c status_pl.c
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
