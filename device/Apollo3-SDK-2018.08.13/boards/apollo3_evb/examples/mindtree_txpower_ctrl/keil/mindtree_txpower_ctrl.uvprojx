# Keil uVision project mindtree_txpower_ctrl.uvprojx, settings and files
target mindtree_txpower_ctrl (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mindtree_txpower_ctrl
  AfterMake: fromelf --bin --output bin\mindtree_txpower_ctrl.bin bin\mindtree_txpower_ctrl.axf
  AfterMake: fromelf -cedrst --output bin\mindtree_txpower_ctrl.txt bin\mindtree_txpower_ctrl.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA TXPOWER_CTRL GAP_CENTRAL APPL_GAP_CENTRAL_SUPPORT DONT_USE_STANDARD_IO AM_DEBUG_PRINTF BT_ENABLE_DISABLE_RUNTIME_DEBUG AM_CUSTOM_BDADDR AM_PART_APOLLO3 AM_FREERTOS keil
  c include: ../../../../..;../../../../../CMSIS/ARM/Include;../../../../../CMSIS/AmbiqMicro/Include;../../../../../ambiq_ble/profile_appl/txpower_ctrl;../../../../../devices;../../../../../mcu/apollo3;../../../../../third_party/ethermind/appl/profile_appl;../../../../../third_party/ethermind/include;../../../../../third_party/ethermind/os/freertos;../../../../../third_party/ethermind/os/freertos/apollo3;../../../../../utils;../../../bsp;../src;../../../../../third_party/FreeRTOS9/Source/include;../../../../../third_party/FreeRTOS9/Source/portable/MemMang;../../../../../third_party/FreeRTOS9/Source/portable/Keil/AMapollo2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\mindtree_txpower_ctrl.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group Source
    ../../../../../third_party/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group MemMang
    ../../../../../third_party/FreeRTOS9/Source/portable/MemMang/: heap_2.c
  group txpower_ctrl
    ../../../../../ambiq_ble/profile_appl/txpower_ctrl/: appl_txpower_ctrl.c
  group apollo3
    ../../../../../third_party/ethermind/os/freertos/apollo3/: hci_drv_apollo3.c
  group src
    ../src/: mindtree_txpower_ctrl.c rtos.c
  group AMapollo2
    ../../../../../third_party/FreeRTOS9/Source/portable/Keil/AMapollo2/: port.c
  group devices
    ../../../../../devices/: am_devices_button.c am_devices_led.c
  group freertos
    ../../../../../third_party/ethermind/os/freertos/: BT_debug.c status_pl.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
    ../../../../../third_party/ethermind/library/freertos/keil/: ethermind.lib
