# IAR project mindtree_pxm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; APPL_GAP_CENTRAL_SUPPORT; GAP_CENTRAL; GAP_OBSERVER; APPL_ATT_CLIENT; ATT_CLIENT; DONT_USE_STANDARD_IO; AM_FREERTOS; APPL_MENU_OPS; AM_DEBUG_PRINTF; BT_ENABLE_DISABLE_RUNTIME_DEBUG; AM_CUSTOM_BDADDR; AM_PART_APOLLO3; AM_FREERTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\devices; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\third_party\ethermind\appl\profile_appl; ..\..\..\..\..\third_party\ethermind\appl\profile_appl\pxm; ..\..\..\..\..\third_party\ethermind\include; ..\..\..\..\..\third_party\ethermind\os\freertos; ..\..\..\..\..\third_party\ethermind\os\freertos\apollo3; ..\..\..\..\..\utils; ..\..\..\bsp; ..\src; ..\..\..\..\..\third_party\FreeRTOS9\Source\include; ..\..\..\..\..\third_party\FreeRTOS9\Source\portable\MemMang; ..\..\..\..\..\third_party\FreeRTOS9\Source\portable\IAR\AMapollo2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mindtree_pxm.bin
  ILINK.IlinkOutputFile: mindtree_pxm.out
  ILINK.IlinkIcfFile: mindtree_pxm.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\..\..\third_party\ethermind\library\freertos\iar\ethermind.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; APPL_GAP_CENTRAL_SUPPORT; GAP_CENTRAL; GAP_OBSERVER; APPL_ATT_CLIENT; ATT_CLIENT; DONT_USE_STANDARD_IO; AM_FREERTOS; APPL_MENU_OPS; AM_DEBUG_PRINTF; BT_ENABLE_DISABLE_RUNTIME_DEBUG; AM_CUSTOM_BDADDR; AM_PART_APOLLO3; AM_FREERTOS
  group (top)
    ../../../../../third_party/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/FreeRTOS9/Source/portable/MemMang/: heap_2.c
    ../../../../../third_party/ethermind/appl/profile_appl/pxm/: appl_pxm.c
    ../../../../../third_party/ethermind/os/freertos/apollo3/: hci_drv_apollo3.c
    ../src/: mindtree_pxm.c rtos.c
    ../../../../../third_party/FreeRTOS9/Source/portable/IAR/AMapollo2/: port.c portasm.s
    ../../../../../devices/: am_devices_led.c
    ../../../../../third_party/ethermind/os/freertos/: BT_debug.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
