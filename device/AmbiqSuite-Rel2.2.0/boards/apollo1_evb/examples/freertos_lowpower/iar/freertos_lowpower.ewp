# IAR project freertos_lowpower.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512-KBR AmbiqMicro APOLLO512-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_DEBUG_PRINTF; AM_FREERTOS; AM_PART_APOLLO; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\bsp; ..\..\..\..\..\mcu\apollo; ..\..\..\..\..\utils; ..\..\..\..\..\devices; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_lowpower.bin
  ILINK.IlinkOutputFile: freertos_lowpower.out
  ILINK.IlinkIcfFile: freertos_lowpower.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_DEBUG_PRINTF; AM_FREERTOS; AM_PART_APOLLO; AM_PACKAGE_BGA
  group (top)
    ../src/: freertos_lowpower.c led_task.c rtos.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo/: port.c portasm.s
    ../../../../../devices/: am_devices_button.c am_devices_led.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
