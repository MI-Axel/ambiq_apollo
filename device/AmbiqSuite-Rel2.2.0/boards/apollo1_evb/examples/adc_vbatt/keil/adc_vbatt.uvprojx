# Keil uVision project adc_vbatt.uvprojx, settings and files
target adc_vbatt (ARM-ADS)
  device: APOLLO512-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc_vbatt
  AfterMake: fromelf --bin --output bin\adc_vbatt.bin bin\adc_vbatt.axf
  AfterMake: fromelf -cedrst --output bin\adc_vbatt.txt bin\adc_vbatt.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO AM_PACKAGE_BGA keil
  c include: ../../../bsp;../../../../../utils;../../../../../mcu/apollo;../../../../../devices;../../../../..;../src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\adc_vbatt.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: adc_vbatt.c
  group devices
    ../../../../../devices/: am_devices_led.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
