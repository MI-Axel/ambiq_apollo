# IAR project multi_boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512-KBR AmbiqMicro APOLLO512-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_MULTIBOOT_CONFIG_FILE="am_multi_boot_config.h"; AM_PACKAGE_BGA; AM_PART_APOLLO
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..; ..\..\..\..\..\devices; ..\..\..\..\..\bootloader; ..\..\..\..\..\mcu\apollo; ..\src; ..\..\..\..\..\utils; ..\..\..\bsp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: multi_boot.bin
  ILINK.IlinkOutputFile: multi_boot.out
  ILINK.IlinkIcfFile: multi_boot.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_MULTIBOOT_CONFIG_FILE="am_multi_boot_config.h"; AM_PACKAGE_BGA; AM_PART_APOLLO
  group (top)
    ../src/: extflash.c multi_boot.c
    ../../../../../bootloader/: am_bootloader.c am_ios_boot_handlers.c am_multi_boot.c am_uart_boot_handlers.c
    ../../../../../devices/: am_devices_spiflash.c
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
    ./: startup_iar.c
