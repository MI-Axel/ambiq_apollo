# Keil uVision project multi_boot.uvprojx, settings and files
target multi_boot (ARM-ADS)
  device: APOLLO512-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: multi_boot
  AfterMake: fromelf --bin --output bin\multi_boot.bin bin\multi_boot.axf
  AfterMake: fromelf -cedrst --output bin\multi_boot.txt bin\multi_boot.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_MULTIBOOT_CONFIG_FILE=\"am_multi_boot_config.h\" AM_PACKAGE_BGA AM_PART_APOLLO keil
  c include: ../../../../..;../../../../../devices;../../../../../bootloader;../../../../../mcu/apollo;../src;../../../../../utils;../../../bsp
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\multi_boot.sct
  link misc: ../../../../../mcu/apollo/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: extflash.c multi_boot.c
  group bootloader
    ../../../../../bootloader/: am_bootloader.c am_ios_boot_handlers.c am_multi_boot.c am_uart_boot_handlers.c
  group devices
    ../../../../../devices/: am_devices_spiflash.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo/hal/keil/bin/: libam_hal.lib
