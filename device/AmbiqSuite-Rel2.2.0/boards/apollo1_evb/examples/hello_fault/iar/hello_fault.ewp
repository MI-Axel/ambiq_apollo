# IAR project hello_fault.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512-KBR AmbiqMicro APOLLO512-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\devices; ..\..\..\..\..\mcu\apollo; ..\..\..\..\..\utils; ..\..\..\bsp; ..\..\..\..\..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: hello_fault.bin
  ILINK.IlinkOutputFile: hello_fault.out
  ILINK.IlinkIcfFile: hello_fault.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO; AM_PACKAGE_BGA
  group (top)
    ../src/: hello_fault.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
