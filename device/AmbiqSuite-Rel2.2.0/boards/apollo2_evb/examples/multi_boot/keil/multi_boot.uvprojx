# Keil uVision project multi_boot.uvprojx, settings and files
target multi_boot (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: multi_boot
  AfterMake: fromelf --bin --output bin\multi_boot.bin bin\multi_boot.axf
  AfterMake: fromelf -cedrst --output bin\multi_boot.txt bin\multi_boot.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO2 AM_MULTIBOOT_CONFIG_FILE=\"am_multi_boot_config.h\" AM_PACKAGE_BGA keil
  c include: ../../../../../utils;../../../bsp;../../../../../devices;../../../../../bootloader;../../../../..;../../../../../mcu/apollo2;../src
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\multi_boot.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: extflash.c multi_boot.c
  group devices
    ../../../../../devices/: am_devices_spiflash.c
  group bootloader
    ../../../../../bootloader/: am_bootloader.c am_ios_boot_handlers.c am_multi_boot.c am_uart_boot_handlers.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
