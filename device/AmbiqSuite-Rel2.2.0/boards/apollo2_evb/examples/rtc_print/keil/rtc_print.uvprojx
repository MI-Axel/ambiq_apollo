# Keil uVision project rtc_print.uvprojx, settings and files
target rtc_print (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtc_print
  AfterMake: fromelf --bin --output bin\rtc_print.bin bin\rtc_print.axf
  AfterMake: fromelf -cedrst --output bin\rtc_print.txt bin\rtc_print.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO2 AM_PACKAGE_BGA keil
  c include: ../../../../../utils;../../../../..;../src;../../../../../mcu/apollo2;../../../../../devices;../../../bsp
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\rtc_print.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: rtc_print.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_string.c am_util_time.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
