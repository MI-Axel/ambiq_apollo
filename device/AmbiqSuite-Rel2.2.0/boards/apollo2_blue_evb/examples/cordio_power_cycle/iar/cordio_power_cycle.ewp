# IAR project cordio_power_cycle.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_DEBUG_PRINTF; WSF_TRACE_ENABLED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\third_party\exactle\ws-core\sw\wsf\ambiq; ..\..\..\..\..\third_party\exactle\ws-core\include; ..\src; ..\..\..\..\..\third_party\exactle\sw\profiles\uribeacon; ..\..\..\..\..\third_party\exactle\sw\apps\app\include; ..\..\..\..\..\third_party\exactle\ws-core\sw\util; ..\..\..\..\..\third_party\exactle\sw\apps\app; ..\..\..\..\..\third_party\exactle\sw\stack\cfg; ..\..\..\..\..\third_party\uecc\micro-ecc; ..\..\..\..\..\third_party\exactle\sw\stack\hci; ..\..\..\..\..\third_party\exactle\sw\profiles\gap; ..\..\..\..\..\third_party\exactle\ws-core\sw\wsf\include; ..\..\..\..\..\mcu\apollo2; ..\..\..\..\..\third_party\exactle\sw\profiles\gatt; ..\..\..\..\..\third_party\exactle\sw\hci\include; ..\..\..\..\..\third_party\exactle\sw\profiles\wdxs; ..\..\..\..\..\third_party\exactle\sw\profiles\hid; ..\..\..\..\..\utils; ..\..\..\..\..\third_party\exactle\sw\sec\include; ..\..\..\bsp; ..\..\..\..\..\third_party\exactle\sw\sec\common; ..\..\..\..\..\third_party\exactle\sw\apps\tag; ..\..\..\..\..\ambiq_ble\em9304; ..\..\..\..\..\third_party\exactle\sw\services; ..\..\..\..\..\third_party\exactle\apollo-host\projects\common; ..\..\..\..\..\third_party\exactle\sw\hci\ambiq; ..\..\..\..\..\devices; ..\..\..\..\..\third_party\exactle\sw\hci\ambiq\em9304; ..\..\..\..\..\third_party\exactle\sw\stack\include; ..\..\..\..\..\third_party\exactle\sw\profiles\fmpl; ..\..\..\..\..\third_party\exactle\sw\profiles\bas
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cordio_power_cycle.bin
  ILINK.IlinkOutputFile: cordio_power_cycle.out
  ILINK.IlinkIcfFile: cordio_power_cycle.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\third_party\exactle\projects\generic\stacklib\iar\bin\libstacklib.a; ..\..\..\..\..\mcu\apollo2\hal\iar\bin\libam_hal.a; ..\..\..\..\..\third_party\uecc\iar\bin\lib_uecc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO2; AM_DEBUG_PRINTF; WSF_TRACE_ENABLED
  group (top)
    ../../../../../third_party/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
    ../src/: cordio_power_cycle.c
    ../../../../../third_party/exactle/sw/profiles/fmpl/: fmpl_main.c
    ../../../../../third_party/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../../../third_party/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
    ../../../../../third_party/exactle/sw/stack/hci/: hci_main.c
    ../../../../../third_party/exactle/sw/profiles/gap/: gap_main.c
    ../../../../../third_party/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
    ../../../../../third_party/exactle/sw/profiles/gatt/: gatt_main.c
    ../../../../../third_party/exactle/sw/profiles/hid/: hid_main.c
    ../../../../../third_party/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
    ../../../../../ambiq_ble/em9304/: em9304_init.c em9304_patches.c
    ../../../../../third_party/exactle/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
    ../../../../../third_party/exactle/sw/apps/hidapp/: hidapp_main.c
    ../../../../../third_party/exactle/sw/hci/ambiq/em9304/: hci_drv_em9304.c
    ../../../../../third_party/exactle/sw/stack/cfg/: cfg_stack.c
    ../../../../../third_party/exactle/sw/profiles/bas/: bas_main.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../third_party/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../../../../third_party/exactle/sw/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../../third_party/exactle/sw/apps/tag/: tag_main.c
    ../../../../../devices/: am_devices_button.c am_devices_em9304.c
    ./: startup_iar.c
