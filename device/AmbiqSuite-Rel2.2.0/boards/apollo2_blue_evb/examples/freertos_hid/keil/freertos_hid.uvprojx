# Keil uVision project freertos_hid.uvprojx, settings and files
target freertos_hid (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_hid
  AfterMake: fromelf --bin --output bin\freertos_hid.bin bin\freertos_hid.axf
  AfterMake: fromelf -cedrst --output bin\freertos_hid.txt bin\freertos_hid.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO2 AM_PACKAGE_BGA AM_FREERTOS AM_DEBUG_PRINTF WSF_TRACE_ENABLED keil
  c include: ../../../../../third_party/exactle/sw/apps/app/include;../../../../../utils;../../../../../third_party/exactle/sw/services;../../../bsp;../../../../../third_party/exactle/sw/profiles/hid;../../../../../third_party/exactle/apollo-host/projects/common;../../../../../third_party/exactle/sw/profiles/bas;../../../../../ambiq_ble/em9304;../../../../../third_party/exactle/ws-core/sw/wsf/include;../../../../../third_party/exactle/sw/sec/common;../../../../../third_party/exactle/sw/hci/include;../../../../../third_party/uecc/micro-ecc;../src;../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../../../third_party/exactle/sw/apps/app;../../../../../third_party/exactle/sw/sec/include;../../../../../third_party/exactle/sw/stack/include;../../../../../third_party/exactle/sw/stack/cfg;../../../../../third_party/exactle/sw/hci/ambiq/em9304;../../../../../mcu/apollo2;../../../../../third_party/FreeRTOSv10.1.1/Source/include;../../../../../third_party/exactle/sw/apps/hidapp;../../../../../devices;../../../../../third_party/exactle/sw/hci/ambiq;../../../../../third_party/exactle/sw/stack/hci;../../../../../third_party/exactle/sw/profiles/uribeacon;../../../../../third_party/exactle/ws-core/include;../../../../../third_party/exactle/ws-core/sw/util;../../../../../third_party/exactle/ws-core/sw/wsf/ambiq
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\freertos_hid.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group exactle_generic
    ../../../../../third_party/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
  group exactle_hrps
    ../../../../../third_party/exactle/sw/profiles/hrps/: hrps_main.c
  group exactle_hid
    ../../../../../third_party/exactle/sw/profiles/hid/: hid_main.c
  group exactle_bas
    ../../../../../third_party/exactle/sw/profiles/bas/: bas_main.c
  group em9304
    ../../../../../ambiq_ble/em9304/: em9304_init.c em9304_patches.c
  group exactle_common
    ../../../../../third_party/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
  group src
    ../src/: freertos_hid.c radio_task.c rtos.c
  group FreeRTOSv10.1.1_AMapollo2
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
  group exactle_cfg
    ../../../../../third_party/exactle/sw/stack/cfg/: cfg_stack.c
  group exactle_em9304
    ../../../../../third_party/exactle/sw/hci/ambiq/em9304/: hci_drv_em9304.c
  group exactle_hidapp
    ../../../../../third_party/exactle/sw/apps/hidapp/: hidapp_main.c
  group exactle_common
    ../../../../../third_party/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
  group exactle_ambiq
    ../../../../../third_party/exactle/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
  group exactle_hci
    ../../../../../third_party/exactle/sw/stack/hci/: hci_main.c
  group exactle_rscp
    ../../../../../third_party/exactle/sw/profiles/rscp/: rscps_main.c
  group exactle_util
    ../../../../../third_party/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
  group exactle_ambiq
    ../../../../../third_party/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
  group FreeRTOSv10.1.1_Source
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group devices
    ../../../../../devices/: am_devices_button.c am_devices_em9304.c
  group utils
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group exactle_services
    ../../../../../third_party/exactle/sw/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
  group exactle_app
    ../../../../../third_party/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
    ../../../../../third_party/exactle/projects/generic/stacklib/keil/Cortex-M4/: libstacklib.lib
    ../../../../../third_party/uecc/keil/bin/: lib_uecc.lib
