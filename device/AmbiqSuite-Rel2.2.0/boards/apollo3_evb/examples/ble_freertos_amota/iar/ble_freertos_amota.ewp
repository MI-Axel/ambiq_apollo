# IAR project ble_freertos_amota.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_DEBUG_PRINTF; AM_FREERTOS; AM_PART_APOLLO3; AM_PACKAGE_BGA; AM_MULTIBOOT_CONFIG_FILE="amota_profile_config.h"; WSF_TRACE_ENABLED; AM_CUSTOM_BDADDR
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\utils; ..\..\..\..\..\third_party\uecc\micro-ecc; ..\..\..\..\..\third_party\exactle\ws-core\sw\wsf\include; ..\..\..\..\..\devices; ..\..\..\..\..\ambiq_ble\profiles\amota; ..\..\..\..\..\third_party\exactle\sw\stack\include; ..\..\..\..\..\third_party\exactle\sw\sec\common; ..\..\..\..\..\third_party\exactle\sw\profiles\uribeacon; ..\..\..\..\..\third_party\exactle\ws-core\sw\util; ..\..\..\..\..\ambiq_ble\apps\amota; ..\..\..\..\..\third_party\exactle\sw\profiles\rscp; ..\..\..\..\..\third_party\exactle\sw\hci\ambiq\apollo3; ..\..\..\..\..\third_party\exactle\sw\stack\cfg; ..\..\..\..\..\third_party\exactle\sw\hci\include; ..\..\..\..\..; ..\..\..\..\..\third_party\exactle\ws-core\sw\wsf\ambiq; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\third_party\exactle\sw\profiles\hrps; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\bootloader; ..\..\..\..\..\third_party\exactle\ws-core\include; ..\..\..\..\..\third_party\exactle\sw\stack\hci; ..\..\..\..\..\ambiq_ble\services; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\mcu\apollo3; ..\src; ..\..\..\..\..\third_party\exactle\apollo-host\projects\common; ..\..\..\bsp; ..\..\..\..\..\third_party\exactle\sw\apps\app; ..\..\..\..\..\third_party\exactle\sw\profiles\bas; ..\..\..\..\..\third_party\exactle\sw\hci\ambiq; ..\..\..\..\..\third_party\exactle\sw\services; ..\..\..\..\..\third_party\exactle\sw\sec\include; ..\..\..\..\..\third_party\exactle\sw\profiles\hid; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\third_party\exactle\sw\apps\app\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_freertos_amota.bin
  ILINK.IlinkOutputFile: ble_freertos_amota.out
  ILINK.IlinkIcfFile: ble_freertos_amota.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\third_party\uecc\iar\bin\lib_uecc.a; ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\..\..\third_party\exactle\projects\generic\stacklib\iar\bin\libstacklib.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_DEBUG_PRINTF; AM_FREERTOS; AM_PART_APOLLO3; AM_PACKAGE_BGA; AM_MULTIBOOT_CONFIG_FILE="amota_profile_config.h"; WSF_TRACE_ENABLED; AM_CUSTOM_BDADDR
  group (top)
    ../../../../../third_party/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
    ../../../../../third_party/exactle/sw/profiles/hrps/: hrps_main.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo2/: port.c portasm.s
    ../../../../../third_party/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
    ../../../../../third_party/exactle/sw/stack/hci/: hci_main.c
    ../../../../../ambiq_ble/services/: svc_amdtp.c svc_amotas.c svc_amvole.c
    ../../../../../third_party/exactle/sw/apps/hidapp/: hidapp_main.c
    ../../../../../ambiq_ble/profiles/amota/: amotas_main.c
    ../../../../../third_party/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../../../third_party/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
    ../../../../../ambiq_ble/apps/amota/: amota_main.c
    ../src/: ble_freertos_amota.c radio_task.c rtos.c
    ../../../../../third_party/exactle/sw/profiles/rscp/: rscps_main.c
    ../../../../../third_party/exactle/sw/hci/ambiq/apollo3/: hci_drv_apollo3.c
    ../../../../../third_party/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
    ../../../../../third_party/exactle/sw/profiles/bas/: bas_main.c
    ../../../../../third_party/exactle/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
    ../../../../../third_party/exactle/sw/stack/cfg/: cfg_stack.c
    ../../../../../third_party/exactle/sw/profiles/hid/: hid_main.c
    ../../../../../utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
    ../../../../../third_party/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../bootloader/: am_bootloader.c am_multi_boot.c
    ../../../../../third_party/exactle/sw/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../../devices/: am_devices_button.c am_devices_led.c
    ./: startup_iar.c
