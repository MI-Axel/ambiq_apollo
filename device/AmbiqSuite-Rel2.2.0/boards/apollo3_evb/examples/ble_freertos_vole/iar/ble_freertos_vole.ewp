# IAR project ble_freertos_vole.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_FREERTOS; AM_PACKAGE_BGA; CUSTOM_SUPPORT; AM_CUSTOM_BDADDR; AM_PART_APOLLO3; AM_DEBUG_PRINTF; HAVE_CONFIG_H; WSF_TRACE_ENABLED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\third_party\exactle\sw\hci\ambiq; ..\..\..\..\..\third_party\exactle\sw\stack\cfg; ..\..\..\..\..; ..\..\..\..\..\third_party\exactle\sw\apps\app; ..\..\..\..\..\third_party\exactle\ws-core\sw\wsf\ambiq; ..\..\..\..\..\third_party\exactle\sw\profiles\bas; ..\..\..\..\..\third_party\exactle\apollo-host\projects\common; ..\..\..\..\..\third_party\exactle\ws-core\sw\wsf\include; ..\..\..\..\..\ambiq_ble\profiles\volecommon; ..\..\..\..\..\ambiq_ble\services; ..\..\..\..\..\third_party\exactle\sw\services; ..\..\..\..\..\third_party\exactle\sw\stack\include; ..\..\..\bsp; ..\..\..\..\..\third_party\exactle\sw\hci\ambiq\apollo3; ..\..\..\..\..\ambiq_ble\apps\vole; ..\..\..\..\..\utils; ..\..\..\..\..\ambiq_ble\profiles\volecommon\codec\sbc; ..\..\..\..\..\third_party\exactle\sw\sec\common; ..\..\..\..\..\third_party\exactle\ws-core\sw\util; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\third_party\exactle\sw\apps\app\include; ..\..\..\..\..\ambiq_ble\profiles\volecommon\codec\opus\opus_optimize\include; ..\..\..\..\..\ambiq_ble\profiles\vole; ..\..\..\..\..\third_party\uecc\micro-ecc; ..\src\vos_src; ..\..\..\..\..\third_party\exactle\sw\hci\include; ..\..\..\..\..\third_party\exactle\sw\sec\include; ..\..\..\..\..\third_party\exactle\sw\profiles\uribeacon; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\ambiq_ble\profiles\volecommon\codec\pb; ..\..\..\..\..\ambiq_ble\profiles\volecommon\codec\opus\opus_optimize\lib; ..\..\..\..\..\third_party\exactle\sw\stack\hci; ..\..\..\..\..\ambiq_ble\profiles\volecommon\codec\opus\opus_optimize\src; ..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\devices; ..\src\vos_include; ..\..\..\..\..\ambiq_ble\profiles\volecommon\codec\opus\opus_optimize\celt; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\third_party\exactle\sw\profiles\hid; ..\..\..\..\..\third_party\exactle\ws-core\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_freertos_vole.bin
  ILINK.IlinkOutputFile: ble_freertos_vole.out
  ILINK.IlinkIcfFile: ble_freertos_vole.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\third_party\exactle\projects\generic\stacklib\iar\bin\libstacklib.a; ..\..\..\..\..\third_party\uecc\iar\bin\lib_uecc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_FREERTOS; AM_PACKAGE_BGA; CUSTOM_SUPPORT; AM_CUSTOM_BDADDR; AM_PART_APOLLO3; AM_DEBUG_PRINTF; HAVE_CONFIG_H; WSF_TRACE_ENABLED
  group (top)
    ../src/: ble_freertos_vole.c radio_task.c rtos.c
    ../../../../../third_party/exactle/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
    ../src/vos_src/: am_app_KWD_AMA.c am_app_KWD_audio.c am_app_KWD_init.c
    ../../../../../third_party/exactle/sw/stack/cfg/: cfg_stack.c
    ../../../../../third_party/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
    ../../../../../third_party/exactle/sw/profiles/bas/: bas_main.c
    ../../../../../ambiq_ble/services/: svc_amdtp.c svc_amotas.c svc_amvole.c
    ../../../../../third_party/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
    ../../../../../ambiq_ble/profiles/volecommon/codec/opus/opus_optimize/lib/: ae_api.c
    ../../../../../ambiq_ble/profiles/volecommon/codec/pb/: accessories.pb.c calling.pb.c central.pb.c common.pb.c device.pb.c media.pb.c pb_common.c pb_decode.c pb_encode.c speech.pb.c state.pb.c system.pb.c transport.pb.c
    ../../../../../third_party/exactle/sw/hci/ambiq/apollo3/: hci_drv_apollo3.c
    ../../../../../ambiq_ble/apps/vole/: vole_main.c
    ../../../../../third_party/exactle/sw/stack/hci/: hci_main.c
    ../../../../../ambiq_ble/profiles/volecommon/codec/sbc/: sbc.c
    ../../../../../third_party/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
    ../../../../../ambiq_ble/profiles/volecommon/codec/opus/opus_optimize/src/: analysis.c mlp.c mlp_data.c oct_opus_encoder.c opus.c repacketizer.c spl_basic_ops.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo2/: port.c portasm.s
    ../../../../../third_party/exactle/sw/apps/hidapp/: hidapp_main.c
    ../../../../../ambiq_ble/profiles/volecommon/codec/opus/opus_optimize/celt/: bands.c celt.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c pitch.c quant_bands.c rate.c vq.c
    ../../../../../third_party/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
    ../../../../../ambiq_ble/profiles/volecommon/: vole_common.c
    ../../../../../third_party/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
    ../../../../../third_party/exactle/sw/profiles/hid/: hid_main.c
    ../../../../../ambiq_ble/profiles/vole/: voles_main.c
    ../../../../../utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
    ../../../../../third_party/exactle/sw/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ../../../../../devices/: am_devices_button.c am_devices_led.c
    ../../../../../third_party/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
    ./: startup_iar.c
