# IAR project opus_step1.ewp, settings and files
configuration tst_with_hdr (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO3; AM_PACKAGE_BGA; OPUS_USER_HDR=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\utils; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\devices; ..\..\..\bsp; ..\..\..\..\..; ..\src; ..\src\sound; ..\lib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\utils; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\devices; ..\..\..\bsp; ..\..\..\..\..; ..\src
  OBJCOPY.OOCOutputFile: opus_step1.bin
  ILINK.IlinkOutputFile: opus_step1.out
  ILINK.IlinkIcfFile: opus_step1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration no_hdr (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: iar; AM_PART_APOLLO3; AM_PACKAGE_BGA; OPUS_USER_HDR=0
  group (top)
    ../../../../../octopus/iar/: ae_api.h
    ../../../../../devices/: am_devices_led.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../src/: opus_step1.c
    ../: README.txt
    ./: startup_iar.c
  group audio
    ../lib/: ae_api.c ae_api.h libopus.a
  group bsp
    ../../../bsp/: am_bsp.c am_bsp_pins.c
  group hal
    ../../../../../mcu/apollo3/hal/: am_hal_adc.c am_hal_ble.c am_hal_ble_patch.c am_hal_burst.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_cmdq.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mspi.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_secure_ota.c am_hal_security.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_wdt.c
