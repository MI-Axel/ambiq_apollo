# IAR project cache_monitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; APS6404L; AM_PACKAGE_BGA; AM_PART_APOLLO3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\apollo3; ..\src; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..; ..\..\..\bsp; ..\..\..\..\..\devices; ..\..\..\..\..\utils; ..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cache_monitor.bin
  ILINK.IlinkOutputFile: cache_monitor.out
  ILINK.IlinkIcfFile: cache_monitor.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; APS6404L; AM_PACKAGE_BGA; AM_PART_APOLLO3
  group (top)
    ../src/: cache_monitor.c
    ../../../../../third_party/prime_mpi/src/: prime_mpi.c
    ../../../../../devices/: am_devices_fireball.c am_devices_mspi_psram.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
