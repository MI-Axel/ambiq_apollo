# IAR project mspi_iom_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_UTIL_FAULTISR_PRINT; FIREBALL_CARD; ENABLE_LOGGING; AM_PART_APOLLO3; CYPRESS_S25FS064S; AM_PACKAGE_BGA; APS6404L
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\devices; ..\..\..\bsp; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..; ..\..\..\..\..\utils; ..\..\..\..\..\CMSIS\ARM\Include; ..\src; ..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mspi_iom_transfer.bin
  ILINK.IlinkOutputFile: mspi_iom_transfer.out
  ILINK.IlinkIcfFile: mspi_iom_transfer.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_UTIL_FAULTISR_PRINT; FIREBALL_CARD; ENABLE_LOGGING; AM_PART_APOLLO3; CYPRESS_S25FS064S; AM_PACKAGE_BGA; APS6404L
  group (top)
    ../src/: mspi_iom_transfer.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../devices/: am_devices_fireball.c am_devices_mb85rs1mt.c am_devices_mspi_flash.c
    ./: startup_iar.c
