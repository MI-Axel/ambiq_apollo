# Keil uVision project mspi_iom_transfer.uvprojx, settings and files
target mspi_iom_transfer (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mspi_iom_transfer
  AfterMake: fromelf --bin --output bin\mspi_iom_transfer.bin bin\mspi_iom_transfer.axf
  AfterMake: fromelf -cedrst --output bin\mspi_iom_transfer.txt bin\mspi_iom_transfer.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_UTIL_FAULTISR_PRINT FIREBALL_CARD ENABLE_LOGGING AM_PART_APOLLO3 CYPRESS_S25FS064S AM_PACKAGE_BGA APS6404L keil
  c include: ../../../../../devices;../../../bsp;../../../../../mcu/apollo3;../../../../..;../../../../../utils;../../../../../CMSIS/ARM/Include;../src;../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\mspi_iom_transfer.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: mspi_iom_transfer.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ../../../../../devices/: am_devices_fireball.c am_devices_mb85rs1mt.c am_devices_mspi_flash.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
