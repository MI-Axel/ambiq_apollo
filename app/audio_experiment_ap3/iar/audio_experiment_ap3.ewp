# IAR project audio_experiment_ap3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_CUSTOM_BDADDR; AM_DEBUG_PRINTF; AM_PART_APOLLO3; CORE_M4; ARM_MATH_CM4; USE_V4_FEATURES; HAVE_CONFIG_H; OPUS_ARM_ASM
  ICCARM.CCIncludePath2: ..\src; ..\include; ..\..\..\device\AmbiqSuite-Rel2.0.0\utils; ..\..\..\device\AmbiqSuite-Rel2.0.0\boards\apollo3_evb\bsp; ..\..\..\device\AmbiqSuite-Rel2.0.0\mcu\apollo3; ..\..\..\device\AmbiqSuite-Rel2.0.0\CMSIS\AmbiqMicro\Include; ..\..\..\device\AmbiqSuite-Rel2.0.0\devices; ..\..\..\app_utils\; ..\..\..\tools\opus\opus-1.3; ..\..\..\tools\opus\opus-1.3\include; ..\..\..\tools\opus\opus-1.3\src; ..\..\..\tools\opus\opus-1.3\celt; ..\..\..\tools\opus\opus-1.3\silk; ..\..\..\tools\opus\opus-1.3\silk\fixed; ..\..\..\tools\opus\opus-1.3\celt\arm; ..\..\..\tools\segger\rtt
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src; ..\include; ..\..\..\device\Apollo3-SDK-2018.08.13\utils; ..\..\..\device\Apollo3-SDK-2018.08.13\boards\apollo3_evb\bsp
  OBJCOPY.OOCOutputFile: audio_experiment_ap3.bin
  ILINK.IlinkOutputFile: audio_experiment_ap3.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: audio_driver.c board_setup.c main.c
    ./: startup_iar.c
  group am_device
    ../../../device/AmbiqSuite-Rel2.0.0/devices/: am_devices_button.c am_devices_led.c
  group am_utils
    ../../../device/AmbiqSuite-Rel2.0.0/utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_regdump.c am_util_stdio.c am_util_string.c am_util_time.c
  group app_utils
    ../../../app_utils/: am_app_utils_ring_buffer.c am_app_utils_rtt_recorder.c
  group bsp
    ../../../device/AmbiqSuite-Rel2.0.0/boards/apollo3_evb/bsp/: am_bsp.c am_bsp_pins.c
  group hal
    ../../../device/AmbiqSuite-Rel2.0.0/mcu/apollo3/hal/: am_hal_adc.c am_hal_ble.c am_hal_ble_patch.c am_hal_ble_patch_b0.c am_hal_burst.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_cmdq.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mspi.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_secure_ota.c am_hal_security.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_wdt.c
  group opus/celt
    ../../../tools/opus/opus-1.3/celt/: bands.c celt.c celt_decoder.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c opus_custom_demo.c pitch.c quant_bands.c rate.c vq.c
  group opus/celt/arm
    ../../../tools/opus/opus-1.3/celt/arm/: armcpu.c
  group opus/silk
    ../../../tools/opus/opus-1.3/silk/: A2NLSF.c ana_filt_bank_1.c biquad_alt.c bwexpander.c bwexpander_32.c check_control_input.c CNG.c code_signs.c control_audio_bandwidth.c control_codec.c control_SNR.c debug.c dec_API.c decode_core.c decode_frame.c decode_indices.c decode_parameters.c decode_pitch.c decode_pulses.c decoder_set_fs.c enc_API.c encode_indices.c encode_pulses.c gain_quant.c HP_variable_cutoff.c init_decoder.c init_encoder.c inner_prod_aligned.c interpolate.c lin2log.c log2lin.c LP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c NLSF2A.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_unpack.c NLSF_VQ.c NLSF_VQ_weights_laroia.c NSQ.c NSQ_del_dec.c pitch_est_tables.c PLC.c process_NLSFs.c quant_LTP_gains.c resampler.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_down_FIR.c resampler_private_IIR_FIR.c resampler_private_up2_HQ.c resampler_rom.c shell_coder.c sigm_Q15.c sort.c stereo_decode_pred.c stereo_encode_pred.c stereo_find_predictor.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_quant_pred.c sum_sqr_shift.c table_LSF_cos.c tables_gain.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_other.c tables_pitch_lag.c tables_pulses_per_block.c VAD.c VQ_WMat_EC.c
  group opus/silk/fixed
    ../../../tools/opus/opus-1.3/silk/fixed/: apply_sine_window_FIX.c autocorr_FIX.c burg_modified_FIX.c corrMatrix_FIX.c encode_frame_FIX.c find_LPC_FIX.c find_LTP_FIX.c find_pitch_lags_FIX.c find_pred_coefs_FIX.c k2a_FIX.c k2a_Q16_FIX.c LTP_analysis_filter_FIX.c LTP_scale_ctrl_FIX.c noise_shape_analysis_FIX.c pitch_analysis_core_FIX.c process_gains_FIX.c regularize_correlations_FIX.c residual_energy16_FIX.c residual_energy_FIX.c schur64_FIX.c schur_FIX.c vector_ops_FIX.c warped_autocorrelation_FIX.c
  group opus/src
    ../../../tools/opus/opus-1.3/src/: analysis.c mlp.c mlp_data.c opus.c opus_compare.c opus_decoder.c opus_encoder.c opus_multistream.c opus_multistream_decoder.c opus_multistream_encoder.c repacketizer.c
  group rtt
    ../../../tools/segger/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
