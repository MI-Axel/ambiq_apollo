# Keil uVision project STM32F407_Discovery.uvprojx, settings and files
target STM32F407_Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F407_Discovery_MDK_ARM
  AfterMake: cscript -nologo elfprocess.js #K .\Objects\STM32F407_Discovery_MDK_ARM.axf ..\..\Bin\MDK-ARM\@L.bin .Objects\STM32F407_Discovery.disasm
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: ENABLE_MIC, USE_HAL_DRIVER, STM32F407xx, CORE_M4, DSPC_CORTEX_M, ARM_MATH_CM4, USE_V4_FEATURES, USE_FLASH_FILE_SYSTEM, HID_INTERFACE, STM32F4XX, USE_STM32F4XX_DISCOVERY, USE_GPIO, USE_FLASH_FILE_SYSTEM,__FPU_PRESENT=1U
  c include: ../../Source;../../../../AWECore/Include;../../Vendor/Source;../../Vendor/Drivers/BSP;../../Vendor/Drivers/STM32F4xx_HAL_Driver/Inc;../../Vendor/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../Vendor/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../Vendor/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc;../../Vendor/Drivers/CMSIS/Include;../../Vendor/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Vendor/Include;../../Examples/GeneratedFiles
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F407_Discovery.sct
  link misc: --diag_suppress=L6329 --pad=0xFF --userlibpath=..\..\Vendor\Drivers\CMSIS\Lib\ARM --userlibpath=..\..\..\..\AWECore\Lib\MDK-ARM  --userlibpath=..\..\Lib\MDK-ARM --userlibpath=..\..\Vendor\Lib\MDK-ARM arm_cortexM4lf_math.lib AWECore.lib Q15_ASRCLib.lib libPDMFilter_CM4_Keil_wc16.lib
  group Drivers/STM32F4xx_HAL_Driver
    ../../Vendor/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_dma.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c
  group Source/AudioWeaver
    ../../Source/: main.c BoardSetup.c AudioDriver.c TuningDriver.c Platform.c GPIO.c USBDescriptors.c AWECoreUtils.c
  group Discovery_board
    ../../Vendor/Drivers/BSP/: cs43l22.c
    ../../Vendor/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./: startup_stm32f407xx.s
    ../../Vendor/Source/: stm32f4_discovery.c stm32f4_discovery_audio.c stm32f4xx_it.c
  group Middlewares/USB_Device_Library
    ../../Vendor/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Vendor/Source/: usb_device.c usbd_audio_if.c usbd_conf.c usbd_desc.c usbd_audio.c
software components: CMSIS:CORE 4.1.0
