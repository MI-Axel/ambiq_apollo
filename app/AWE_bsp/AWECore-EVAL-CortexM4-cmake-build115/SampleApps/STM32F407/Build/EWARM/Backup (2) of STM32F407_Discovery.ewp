# IAR project Backup (2) of STM32F407_Discovery.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ENABLE_MIC; USE_HAL_DRIVER; STM32F407xx; CORE_M4; DSPC_CORTEX_M; ARM_MATH_CM4; USE_V4_FEATURES; USE_FLASH_FILE_SYSTEM; HID_INTERFACE; STM32F4XX; USE_STM32F4XX_DISCOVERY; USE_DEFAULT_TIMEOUT_CALLBACK; PROFILE_TIMES; EXTERNMODULETABLE; USE_GPIO; _DLIB_FILE_DESCRIPTOR; __FPU_PRESENT=1U
  ICCARM.CCIncludePath2: ..\..\Source; ..\..\..\..\AWECore\Include\; ..\..\Vendor\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Vendor\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\Vendor\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\Vendor\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\Vendor\Drivers\CMSIS\Include; ..\..\Vendor\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Vendor\Drivers\BSP; ..\..\Vendor\Include; ..\..\Vendor\Source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\Bin\EWARM\STM32F407_Discovery_EWARM.bin
  ILINK.IlinkOutputFile: STM32F407_Discovery.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkExtraOptions: --diag_suppress Lt009
  ILINK.IlinkAdditionalLibs: ..\..\..\..\AWECore\Lib\EWARM\AWECore.a; ..\..\Lib\EWARM\Q15_ASRCLib.a; ..\..\Vendor\Lib\EWARM\libPDMFilter_CM4_IAR_wc16.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ENABLE_MIC; USE_HAL_DRIVER; STM32F407xx; CORE_M4; DSPC_CORTEX_M; ARM_MATH_CM4; USE_FLASH_FILE_SYSTEM; HID_INTERFACE; STM32F4XX; USE_STM32F4XX_DISCOVERY; USE_DEFAULT_TIMEOUT_CALLBACK; USE_GPIO; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCOptLevel: 0
  ILINK.IlinkAdditionalLibs: ..\..\..\..\AWECore\Lib\EWARM\AWECore.a; ..\..\Lib\EWARM\Q15_ASRCLib.a; ..\..\Vendor\Lib\EWARM\libPDMFilter_CM4_IAR_wc16.a; ..\..\Lib\EWARM\STModules_IAR_M4.a; ..\..\Vendor\Lib\EWARM\SDR_32b_CM4_IAR.a; ..\..\Vendor\Lib\EWARM\BAM_32b_CM4_IAR.a; ..\..\Vendor\Lib\EWARM\BIQ_32b_CM4_IAR.a; ..\..\Vendor\Lib\EWARM\GAM_32b_CM4_IAR.a; ..\..\Vendor\Lib\EWARM\GrEq_32b_CM4_IAR.a; ..\..\Vendor\Lib\EWARM\HPV_HQ_32b_CM4_IAR.a; ..\..\Vendor\Lib\EWARM\OMNI2_SW_32b_CM4_IAR.a; ..\..\Vendor\Lib\EWARM\SMR_32b_CM4_IAR.a; ..\..\Vendor\Lib\EWARM\SVC_32b_CM4_IAR.a; ..\..\Vendor\Lib\EWARM\OMNI2_MC_32b_CM4_IAR.a
  group Application/EWARM
    ../../Vendor/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../../Vendor/Source/: stm32f4_discovery.c stm32f4_discovery_audio.c stm32f4xx_it.c
    ../../Vendor/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../../Source/: AudioDriver.c AWECoreUtils.c BoardSetup.c GPIO.c main.c Platform.c TuningDriver.c USBDescriptors.c
  group Drivers
    ../../Vendor/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
  group Middlewares/USB_Device_Library
    ../../Vendor/Drivers/BSP/: cs43l22.c
    ../../Vendor/Source/: usb_device.c usbd_audio.c usbd_audio_if.c usbd_conf.c usbd_desc.c
    ../../Vendor/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
