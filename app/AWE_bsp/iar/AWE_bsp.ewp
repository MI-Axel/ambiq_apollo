# IAR project AWE_bsp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_CUSTOM_BDADDR; AM_DEBUG_PRINTF; AM_PART_APOLLO3; CORE_M4; DSPC_CORTEX_M; ARM_MATH_CM4; USE_V4_FEATURES; USE_GPIO
  ICCARM.CCIncludePath2: ..\Source; ..\..\..\device\AmbiqSuite-Rel2.0.0\mcu\apollo3\hal; ..\..\..\device\AmbiqSuite-Rel2.0.0\boards\apollo3_evb\bsp; ..\..\..\device\AmbiqSuite-Rel2.0.0\mcu\apollo3; ..\..\..\device\AmbiqSuite-Rel2.0.0\CMSIS\AmbiqMicro\Include; ..\..\..\device\AmbiqSuite-Rel2.0.0\devices; ..\Lib\AWEInclude; ..\Lib\AWEInclude\Modules; ..\Lib\AWEInclude\Targets; ..\..\..\device\AmbiqSuite-Rel2.0.0\utils
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AWE_bsp.srec
  ILINK.IlinkOutputFile: AWE_bsp.out
  ILINK.IlinkAdditionalLibs: ..\..\..\device\AmbiqSuite-Rel2.0.0\boards\apollo3_evb\bsp\iar\bin\libam_bsp.a; ..\..\..\device\AmbiqSuite-Rel2.0.0\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\Lib\AWELibs\EWARM\CFramework.a; ..\Lib\AWELibs\EWARM\ModuleHelperLib.a; ..\Lib\AWELibs\EWARM\Standard.a; ..\Lib\AWELibs\EWARM\Advanced.a; ..\Lib\AWELibs\EWARM\Q15_Demo_ASRCLib.a; ..\Lib\AWELibs\EWARM\VectorLib.a; ..\Lib\AWELibs\EWARM\dspc_qsd.a; ..\Lib\AWELibs\EWARM\dspc_scnr.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Source/: AudioDriver.c AWEFlash.c BoardSetup.c ControlDriver.c GPIO.c main.c Platform.c TuningDriver.c TuningHandler.c
    ./: startup_iar.c
  group am_bsp
    ../../../device/AmbiqSuite-Rel2.0.0/boards/apollo3_evb/bsp/: am_bsp.c am_bsp_pins.c
  group am_devices
    ../../../device/AmbiqSuite-Rel2.0.0/devices/: am_devices_button.c am_devices_led.c
  group am_hal
    ../../../device/AmbiqSuite-Rel2.0.0/mcu/apollo3/hal/: am_hal_adc.c am_hal_ble.c am_hal_ble_patch.c am_hal_ble_patch_b0.c am_hal_burst.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_cmdq.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mspi.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_secure_ota.c am_hal_security.c am_hal_stimer.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_wdt.c
  group am_util
    ../../../device/AmbiqSuite-Rel2.0.0/utils/: am_util_ble.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_regdump.c am_util_stdio.c am_util_string.c am_util_time.c
  group dspc_layout
    ../Source/: AM_2cm_FBF_SCNR_THF_NTAWB.c
